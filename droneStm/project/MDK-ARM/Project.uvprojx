# Keil uVision project Project.uvprojx, settings and files
target TCopter (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F427_437xx +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F427_437xx, HSE_VALUE = 8000000
  c misc: --C99 --cpp
  c include: ..\..\project;..\MDK-ARM;..\..\libs\service\gpio;..\..\libs\service\delay;..\..\libs\service\uart;..\..\libs\service\i2c;..\..\libs\service\timer;..\..\libs\service\timerutil;..\..\libs\service\controller;..\..\libs\service\mapper;..\..\libs\service\systemtick;..\..\libs\service\time;..\..\libs\service\motorcontrol;..\..\libs\service\mpu9250;..\..\libs\service\tileni2c;..\..\libs\service\data;..\..\libs\service\util;..\..\libs\service\calibrate;..\..\libs\service\pid;..\..\libs\service\eulercalculator;..\..\libs\application\config;..\..\libs\application\core;..\..\libs\application\imublock;..\..\libs\application\printer;..\..\libs\application\eulerblock;..\..\libs\application\motorcontrol;..\..\libs\application\flycontrolblock;..\..\libs\service\filter;..\..\libs\service\buffer;..\..\miniprogram\GyroCalibrationProgram;..\..\libs\lowlayer\store;..\..\libs\service\dronestore;..\..\miniprogram\debug;..\..\libs\service\pinstatereader;..\..\libs\service\barometer\ms5611;..\..\miniprogram\altitudecalibrationprogram;..\..\libs\application\altitudeblock;..\..\libs\service\ubx;..\..\libs\service\ublox;..\..\libs\algorithm\holdaltitude;..\..\libs\service\translate;..\..\libs\algorithm\holdposition;..\..\libs\application\gpsb;..\..\libs\drivers\CMSIS\Include;..\..\libs\drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\libs\drivers\STM32F4xx_StdPeriph_Driver\inc;..\..\libs\middleware\gpio;..\..\libs\middleware\communication\i2c;..\..\test\middleware_test\inc;..\..\libs\lib\data;..\..\libs\lib\peripherals\mpu9250;..\..\libs\middleware\time;..\..\libs\middleware\sensors;..\..\libs\system\imu;..\..\libs\system\gps;..\MDK-ARM;..\..\libs\middleware\receiver;..\..\libs\middleware\euler_calculator;..\..\libs\system\euler;..\..\libs\system\controller;..\..\libs\error_handler;..\..\libs\system\altitude;..\..\libs\pid;..\..\libs\system\fly
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group stm32f4xx_standar_lib
    ../../libs/drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group cmsis
    ../../libs/drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group star_up
    ../../libs/drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group time
    ../../libs/middleware/time/: MTime.c MTime.h
  group gpio
    ../../libs/middleware/gpio/: GpioUtils.c GpioUtils.h
  group i2c
    ../../libs/middleware/communication/i2c/: I2C.c I2C.h I2CUtils.c I2CUtils.h
  group uart
    ../../libs/middleware/communication/uart/: UART.h UART.cpp
  group data
    ../../libs/lib/data/: ArrayUtils.h ArrayUtils.cpp Data.h Data.c Constraint.h Constraint.cpp
  group timeout
    ../../libs/std_time/: Timeout.c Timeout.h
    ../../libs/pid/: Pid.h
  group mpu9250
    ../../libs/lib/peripherals/mpu9250/: MPU9250.c MPU9250.h
  group pid
    ../../libs/pid/: Pid.h Pid.cpp
  group calibrate
    ../../libs/algorithm/calibrate/: Calibrate.cpp Calibrate.h
  group mid_sensors
    ../../libs/middleware/sensors/: MiddleSensor.cpp MiddleSensor.h
  group mid_receiver
    ../../libs/middleware/receiver/: MiddleReceiver.c MiddleReceiver.h
  group mid_euler_cal
    ../../libs/middleware/euler_calculator/: MiddleEulerCalculator.c MiddleEulerCalculator.h
  group sy_imu
    ../../libs/system/imu/: ImuSystem.h ImuSystem.cpp
  group sy_altitude
    ../../libs/system/altitude/: AltitudeSystem.c AltitudeSystem.h
  group sy_gps
    ../../libs/system/gps/: GpsSystem.c GpsSystem.h
  group sy_control
    ../../libs/system/controller/: ControllerSystem.c ControllerSystem.h ControllerSystemCallback.h
  group sy_euler_angle
    ../../libs/system/euler/: EulerSystem.h EulerSystem.c
  group sy_fly
    ../../libs/system/fly/: AltitudeHoldingSystem.c AltitudeHoldingSystem.h BalancingSystem.c BalancingSystem.h PositionHoldingSystem .c PositionHoldingSystem.h
  group control_center
    ../../libs/control_center/: ControlCenter.c ControlCenter.h
  group main
    ./: _main.c _main.h
  group error_handler
    ../../libs/error_handler/: ErrorHandler.c ErrorHandler.h
  group test
    ../../test/middleware_test/src/: I2CTest.c
software components: CMSIS:CORE 5.0.0
